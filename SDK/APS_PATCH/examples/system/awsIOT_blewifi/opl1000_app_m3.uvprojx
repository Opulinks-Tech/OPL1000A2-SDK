# Keil uVision project opl1000_app_m3.uvprojx, settings and files
target OPL1000_APP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: opl1000_app_m3 +hex
  AfterMake: .\opl1000_app_m3.bat $L !L @L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __noSIMULATOR__ __BLE__ __LE_HOST_USE_CMD__ __LWIP_TASK__ __WPA_SUPPLICANT__ __noHW_CRYPTO_ENGINE__ __WIFI_MAC_TASK__ __NL1000_An__ __PMP_ENABLE__ __PMP_REGION__ __HEAP_REGION__ noLWIP_DYNAMIC_DEBUG_ENABLE __AT_CMD_TASK__ __noRTL_SIMULATION__ __WIFI_AUTO_CONNECT__ OPL1000_APS
  c misc: --preinclude=sys_common.h
  c include: .\amazon-freertos_v1.4.8\demos\opulinks\OPL1000\common\config_files;.\amazon-freertos_v1.4.8\demos\opulinks\OPL1000\common\application_code;.\amazon-freertos_v1.4.8\lib\include;.\amazon-freertos_v1.4.8\lib\include\private;.\amazon-freertos_v1.4.8\lib\third_party\pkcs11;.\amazon-freertos_v1.4.8\lib\third_party\jsmn;.\amazon-freertos_v1.4.8\demos\common\include;..\..\..\..\APS\FreeRtos\Source\include;..\..\..\..\APS\middleware\third_party\mbedtls\include\mbedtls;..\..\..\..\APS\middleware\third_party\mbedtls\include;..\..\..\..\APS\FreeRtos\Source\include;..\..\..\..\APS\FreeRtos\Source\portable\Keil\ARM_CM3;..\..\..\..\APS\driver\CMSIS\Include;..\..\..\..\APS\driver\CMSIS\Device\opl1000\Include;..\..\..\..\APS\driver\chip;..\..\..\..\APS\driver\chip\opl1000\securityipdriver;..\..\..\..\APS\driver\chip\opl1000\hal_auxadc;..\..\..\..\APS\driver\chip\opl1000\hal_system;..\..\..\..\APS\driver\chip\opl1000\hal_patch;..\..\..\..\APS\driver\chip\opl1000\hal_uart;..\..\..\..\APS\driver\chip\opl1000\hal_spi;..\..\..\..\APS\driver\chip\opl1000\hal_vic;..\..\..\..\APS\driver\chip\opl1000\hal_dbg_uart;..\..\..\..\APS\driver\chip\opl1000\hal_wdt;..\..\..\..\APS\driver\chip\opl1000\hal_dma;..\..\..\..\APS\driver\chip\opl1000\hal_tmr;..\..\..\..\APS\driver\chip\opl1000\hal_tick;..\..\..\..\APS\driver\chip\opl1000\hal_pwm;..\..\..\..\APS\driver\chip\opl1000\hal_i2c;..\..\..\..\APS\project\opl1000\include;..\..\..\..\APS\project\common;..\..\..\..\APS\middleware\netlink;..\..\..\..\APS\middleware\netlink\cli;..\..\..\..\APS\middleware\netlink\msg;..\..\..\..\APS\middleware\netlink\mw_fim;..\..\..\..\APS\middleware\netlink\mw_ota;..\..\..\..\APS\middleware\netlink\data_flow;..\..\..\..\APS\middleware\netlink\wifi_controller_layer;..\..\..\..\APS\middleware\netlink\ble_controller_layer\inc;..\..\..\..\APS\middleware\netlink\le_stack;..\..\..\..\APS\middleware\netlink\at;..\..\..\..\APS\middleware\netlink\iperf\inc;..\..\..\..\APS\middleware\netlink\controller_task;..\..\..\..\APS\middleware\netlink\ps_task;..\..\..\..\APS\middleware\netlink\diag_task;..\..\..\..\APS\middleware\netlink\wifi_controller_layer\rom_if;..\..\..\..\APS\middleware\netlink\wifi_mac;..\..\..\..\APS\middleware\netlink\common\sys_api;..\..\..\..\APS\middleware\netlink\common\sys_ctrl;..\..\..\..\APS\apps\le_app\pts_app;..\..\..\..\APS\apps\le_app\mtc_app;..\..\..\..\APS\apps\le_app\cmd_app;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\utils;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\common;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\eap_common;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\eap_peer;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\eapol_supp;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\eapol_auth;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\radius;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\crypto;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\drivers;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\rsn_supp;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\l2_packet;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\ap;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\wps;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant\dbus;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\lwip\src\include;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\ports\freertos\include;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\ports\freertos\netif;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\ports\rom_if;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\;..\..\..\..\APS\middleware\third_party\tinycrypt\include;..\..\..\..\APS\middleware\third_party\mbedtls\include;..\..\..\..\APS\project\opl1000\boot_sequence;..\..\..\..\APS\project\opl1000\startup;..\..\..\apps\le_app\include;..\..\..\driver\chip\opl1000;..\..\..\driver\chip\opl1000\hal_auxadc;..\..\..\driver\chip\opl1000\hal_spi;..\..\..\driver\chip\opl1000\hal_system;..\..\..\driver\chip\opl1000\securityipdriver;..\..\..\project\opl1000\startup;..\..\..\project\opl1000\include;..\..\..\middleware\netlink\data_flow;..\..\..\middleware\netlink\msg;..\..\..\middleware\netlink\mw_fim;..\..\..\middleware\netlink\mw_ota;..\..\..\middleware\netlink\ble_controller_layer\inc;..\..\..\middleware\netlink\le_stack\patch;..\..\..\middleware\netlink\le_stack\cmd_app;..\..\..\middleware\netlink\le_stack\pts_app;..\..\..\middleware\netlink\le_stack\mtc_app;..\..\..\middleware\netlink\at;..\..\..\middleware\netlink\diag_task;..\..\..\middleware\netlink\wifi_controller_layer;..\..\..\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant;..\..\..\middleware\third_party\wpa_supplicant-0.7.3\src\utils;..\..\..\middleware\third_party\wpa_supplicant-0.7.3\src\rsn_supp;..\..\..\middleware\netlink\wifi_mac;..\..\..\middleware\third_party\wpa_supplicant-0.7.3\src\drivers;..\..\..\middleware\netlink\wifi_controller_layer\rom_if;..\..\..\middleware\third_party\lwip-2.0.3\ports\rom_if;..\..\..\middleware\third_party\httpclient;..\..\..\middleware\netlink\ps_task;..\..\..\middleware\third_party\lwip-2.0.3\lwip\src\include;.\src;.\src\iot_data;..\..\..\middleware\third_party\lwip-2.0.3\lwip\src\include\lwip
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xc0000
  memory RVCT9: RAM 0x400000 size 0x50000
  scatter file: .\opl1000_app_m3.sct
  link misc: --datacompressor off --entry=__Patch_EntryPoint
  group src
    ./src/: main_patch.c blewifi_app.c blewifi_common.c blewifi_ctrl.c blewifi_data.c blewifi_server_app.c blewifi_server_app_gatt.c blewifi_ctrl_http_ota.c blewifi_http_ota.c blewifi_ble_api.c blewifi_wifi_api.c app_at_cmd.c mw_fim_default_group11_project.c mw_fim_default_group12_project.c
  group iot_data
    ./src/iot_data/: iot_data.c
  group object
    ../../../../APS/targets/opl1000/object/: symdefs.o
    ../../../../APS/targets/opl1000/Output/Objects/: opl1000_patch_m3.lib opl1000_sdk_m3.lib
  group demos
    ./amazon-freertos_v1.4.8/demos/common/devmode_key_provisioning/: aws_dev_mode_key_provisioning.c
    ./amazon-freertos_v1.4.8/demos/common/logging/: aws_logging_task_dynamic_buffers.c
    ./amazon-freertos_v1.4.8/demos/common/mqtt/: aws_hello_world.c aws_subscribe_publish_loop.c
    ./amazon-freertos_v1.4.8/demos/common/shadow/: aws_shadow_lightbulb_on_off.c
    ./amazon-freertos_v1.4.8/lib/utils/: aws_system_init.c
  group lib/FreeRTOS
    ./amazon-freertos_v1.4.8/lib/FreeRTOS/: stream_buffer.c
  group lib/mqtt
    ./amazon-freertos_v1.4.8/lib/mqtt/: aws_mqtt_agent.c aws_mqtt_lib.c
  group lib/third_party/jsmn
    ./amazon-freertos_v1.4.8/lib/third_party/jsmn/: jsmn.c
  group lib/shadow
    ./amazon-freertos_v1.4.8/lib/shadow/: aws_shadow.c aws_shadow_json.c
  group lib/bufferpool
    ./amazon-freertos_v1.4.8/lib/bufferpool/: aws_bufferpool_static_thread_safe.c
  group lib/secure_sockets
    ./amazon-freertos_v1.4.8/lib/secure_sockets/portable/lwip/: aws_secure_sockets.c
  group lib/pkcs11
    ./amazon-freertos_v1.4.8/lib/pkcs11/mbedtls/: aws_pkcs11_mbedtls.c
    ./amazon-freertos_v1.4.8/lib/pkcs11/portable/opulinks/board/: aws_pkcs11_pal.c
  group lib/tls
    ./amazon-freertos_v1.4.8/lib/tls/: aws_tls.c
  group lib/third_party/mbedtls
    ./amazon-freertos_v1.4.8/lib/third_party/mbedtls/library/: pem.c pkwrite.c
