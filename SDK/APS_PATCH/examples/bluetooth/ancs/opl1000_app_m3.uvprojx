# Keil uVision project opl1000_app_m3.uvprojx, settings and files
target OPL1000_APP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: opl1000_app_m3 +hex
  AfterMake: .\opl1000_app_m3.bat $L !L @L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __noSIMULATOR__ __BLE__ __LE_HOST_USE_CMD__ __LWIP_TASK__ __WPA_SUPPLICANT__ __noHW_CRYPTO_ENGINE__ __WIFI_MAC_TASK__ __NL1000_An__ __PMP_ENABLE__ __PMP_REGION__ __HEAP_REGION__ noLWIP_DYNAMIC_DEBUG_ENABLE __AT_CMD_TASK__ __noRTL_SIMULATION__ __WIFI_AUTO_CONNECT__ OPL1000_APS
  c misc: --preinclude=sys_common.h
  c include: ..\..\..\..\APS\apps\le_app\cmd_app;..\..\..\..\APS\apps\le_app\mtc_app;..\..\..\..\APS\apps\le_app\pts_app;..\..\..\..\APS\apps\wifi_app;..\..\..\..\APS\driver\chip\opl1000\hal_auxadc;..\..\..\..\APS\driver\chip\opl1000\hal_dbg_uart;..\..\..\..\APS\driver\chip\opl1000\hal_dma;..\..\..\..\APS\driver\chip\opl1000\hal_i2c;..\..\..\..\APS\driver\chip\opl1000\hal_patch;..\..\..\..\APS\driver\chip\opl1000\hal_pwm;..\..\..\..\APS\driver\chip\opl1000\hal_spi;..\..\..\..\APS\driver\chip\opl1000\hal_system;..\..\..\..\APS\driver\chip\opl1000\hal_tick;..\..\..\..\APS\driver\chip\opl1000\hal_tmr;..\..\..\..\APS\driver\chip\opl1000\hal_uart;..\..\..\..\APS\driver\chip\opl1000\hal_vic;..\..\..\..\APS\driver\chip\opl1000\hal_wdt;..\..\..\..\APS\driver\chip\opl1000\securityipdriver;..\..\..\..\APS\driver\CMSIS\Device\opl1000\Include;..\..\..\..\APS\driver\CMSIS\Include;..\..\..\..\APS\FreeRtos\Source\include;..\..\..\..\APS\FreeRtos\Source\portable\Keil\ARM_CM3;..\..\..\..\APS\middleware\netlink\at;..\..\..\..\APS\middleware\netlink\ble_controller_layer\inc;..\..\..\..\APS\middleware\netlink\cli;..\..\..\..\APS\middleware\netlink\common\sys_api;..\..\..\..\APS\middleware\netlink\common\sys_api\rom_if;..\..\..\..\APS\middleware\netlink\common\sys_ctrl;..\..\..\..\APS\middleware\netlink\controller_task;..\..\..\..\APS\middleware\netlink\data_flow;..\..\..\..\APS\middleware\netlink\diag_task;..\..\..\..\APS\middleware\netlink\msg;..\..\..\..\APS\middleware\netlink\mw_fim;..\..\..\..\APS\middleware\netlink\mw_ota;..\..\..\..\APS\middleware\netlink\ps_task;..\..\..\..\APS\middleware\netlink\wifi_controller_layer;..\..\..\..\APS\middleware\netlink\wifi_controller_layer\rom_if;..\..\..\..\APS\middleware\netlink\wifi_mac;..\..\..\..\APS\middleware\netlink\wifi_mac\common;..\..\..\..\APS\middleware\netlink\wifi_mac\crypto;..\..\..\..\APS\middleware\netlink\wifi_mac\utils;..\..\..\..\APS\middleware\third_party\fatfs\src;..\..\..\..\APS\middleware\third_party\httpclient;..\..\..\..\APS\middleware\third_party\lwip-2.0.3;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\lwip\src\include\;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\lwip\src\include\lwip;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\ports\freertos\include;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\ports\freertos\netif;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\ports\rom_if;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\ports\rom_if\api;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\ports\rom_if\ipv4;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\ports\rom_if\ipv6;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\ports\rom_if\netif;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\ports\rom_if\port;..\..\..\..\APS\middleware\third_party\mbedtls\configs;..\..\..\..\APS\middleware\third_party\mbedtls\include\mbedtls;..\..\..\..\APS\middleware\third_party\mbedtls\port\include;..\..\..\..\APS\middleware\third_party\tinycrypt\include\tinycrypt;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\ap;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\common;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\crypto;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\drivers;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\eapol_auth;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\eapol_supp;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\eap_common;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\eap_peer;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\eap_server;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\l2_packet;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\radius;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\rsn_supp;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\tls;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\utils;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\wps;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant\dbus;..\..\..\..\APS\project\common;..\..\..\..\APS\project\opl1000\boot_sequence;..\..\..\..\APS\project\opl1000\include;..\..\..\..\APS\project\opl1000\startup;..\..\..\apps\le_app\cmd_app;..\..\..\apps\le_app\include;..\..\..\apps\le_app\mtc_app;..\..\..\apps\le_app\pts_app;..\..\..\apps\wifi_app;..\..\..\driver\chip\opl1000\hal_auxadc;..\..\..\driver\chip\opl1000\hal_dbg_uart;..\..\..\driver\chip\opl1000\hal_dma;..\..\..\driver\chip\opl1000\hal_i2c;..\..\..\driver\chip\opl1000\hal_patch;..\..\..\driver\chip\opl1000\hal_pwm;..\..\..\driver\chip\opl1000\hal_spi;..\..\..\driver\chip\opl1000\hal_system;..\..\..\driver\chip\opl1000\hal_tick;..\..\..\driver\chip\opl1000\hal_tmr;..\..\..\driver\chip\opl1000\hal_uart;..\..\..\driver\chip\opl1000\hal_vic;..\..\..\driver\chip\opl1000\hal_wdt;..\..\..\driver\chip\opl1000\securityipdriver;..\..\..\driver\CMSIS\Device\opl1000\Include;..\..\..\driver\CMSIS\Include;..\..\..\FreeRtos\Source\include;..\..\..\FreeRtos\Source\portable\Keil\ARM_CM3;..\..\..\middleware\netlink\at;..\..\..\middleware\netlink\ble_controller_layer\inc;..\..\..\middleware\netlink\cli;..\..\..\middleware\netlink\common\sys_api;..\..\..\middleware\netlink\common\sys_api\rom_if;..\..\..\middleware\netlink\common\sys_ctrl;..\..\..\middleware\netlink\controller_task;..\..\..\middleware\netlink\data_flow;..\..\..\middleware\netlink\diag_task;..\..\..\middleware\netlink\msg;..\..\..\middleware\netlink\mw_fim;..\..\..\middleware\netlink\mw_ota;..\..\..\middleware\netlink\ps_task;..\..\..\middleware\netlink\wifi_controller_layer;..\..\..\middleware\netlink\wifi_controller_layer\rom_if;..\..\..\middleware\netlink\wifi_mac;..\..\..\middleware\netlink\wifi_mac\common;..\..\..\middleware\netlink\wifi_mac\crypto;..\..\..\middleware\netlink\wifi_mac\utils;..\..\..\middleware\third_party\fatfs\src;..\..\..\middleware\third_party\httpclient;..\..\..\middleware\third_party\lwip-2.0.3;..\..\..\middleware\third_party\lwip-2.0.3\lwip\src\include;..\..\..\middleware\third_party\lwip-2.0.3\lwip\src\include\lwip;..\..\..\middleware\third_party\lwip-2.0.3\lwip\src\include\netif;..\..\..\middleware\third_party\lwip-2.0.3\lwip\src\include\netif\ppp;..\..\..\middleware\third_party\lwip-2.0.3\lwip\src\include\netif\ppp\polarssl;..\..\..\middleware\third_party\lwip-2.0.3\lwip\src\include\posix;..\..\..\middleware\third_party\lwip-2.0.3\lwip\src\include\posix\sys;..\..\..\middleware\third_party\lwip-2.0.3\ports\freertos\include;..\..\..\middleware\third_party\lwip-2.0.3\ports\freertos\netif;..\..\..\middleware\third_party\lwip-2.0.3\ports\rom_if;..\..\..\middleware\third_party\lwip-2.0.3\ports\rom_if\api;..\..\..\middleware\third_party\lwip-2.0.3\ports\rom_if\ipv4;..\..\..\middleware\third_party\lwip-2.0.3\ports\rom_if\ipv6;..\..\..\middleware\third_party\lwip-2.0.3\ports\rom_if\netif;..\..\..\middleware\third_party\lwip-2.0.3\ports\rom_if\port;..\..\..\middleware\third_party\mbedtls\configs;..\..\..\middleware\third_party\mbedtls\include\mbedtls;..\..\..\middleware\third_party\mbedtls\port\include;..\..\..\middleware\third_party\tinycrypt\include\tinycrypt;..\..\..\middleware\third_party\wpa_supplicant-0.7.3\src\ap;..\..\..\middleware\third_party\wpa_supplicant-0.7.3\src\common;..\..\..\middleware\third_party\wpa_supplicant-0.7.3\src\crypto;..\..\..\middleware\third_party\wpa_supplicant-0.7.3\src\drivers;..\..\..\middleware\third_party\wpa_supplicant-0.7.3\src\eapol_auth;..\..\..\middleware\third_party\wpa_supplicant-0.7.3\src\eapol_supp;..\..\..\middleware\third_party\wpa_supplicant-0.7.3\src\eap_common;..\..\..\middleware\third_party\wpa_supplicant-0.7.3\src\eap_peer;..\..\..\middleware\third_party\wpa_supplicant-0.7.3\src\eap_server;..\..\..\middleware\third_party\wpa_supplicant-0.7.3\src\l2_packet;..\..\..\middleware\third_party\wpa_supplicant-0.7.3\src\radius;..\..\..\middleware\third_party\wpa_supplicant-0.7.3\src\rsn_supp;..\..\..\middleware\third_party\wpa_supplicant-0.7.3\src\tls;..\..\..\middleware\third_party\wpa_supplicant-0.7.3\src\utils;..\..\..\middleware\third_party\wpa_supplicant-0.7.3\src\wps;..\..\..\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant;..\..\..\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant\dbus;..\..\..\project\common;..\..\..\project\opl1000\boot_sequence;..\..\..\project\opl1000\include;..\..\..\project\opl1000\startup
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xc0000
  memory RVCT9: RAM 0x400000 size 0x50000
  scatter file: .\opl1000_app_m3.sct
  link misc: --datacompressor off --entry=__Patch_EntryPoint
  group source
    ./: main_patch.c ancs_app.c ancs_app_gatt.c ancs_app_client.c
  group object
    ../../../../APS/targets/opl1000/object/: symdefs.o
    ../../../../APS/targets/opl1000/Output/Objects/: opl1000_patch_m3.lib opl1000_sdk_m3.lib
