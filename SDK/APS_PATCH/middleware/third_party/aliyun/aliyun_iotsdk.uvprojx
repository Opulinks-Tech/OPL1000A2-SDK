# Keil uVision project aliyun_iotsdk.uvprojx, settings and files
target linkkit_sdk (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.1.1
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: libiot_sdk +hex (library)
  AfterMake: .\aliyun_iotsdk.bat $L !L @L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: OPL1000_APS __noSIMULATOR__ __BLE__ __LE_HOST_USE_CMD__ __LWIP_TASK__ __WPA_SUPPLICANT__ __noHW_CRYPTO_ENGINE__ __WIFI_MAC_TASK__ __NL1000_An__ __PMP_ENABLE__ __PMP_REGION__ __HEAP_REGION__ noLWIP_DYNAMIC_DEBUG_ENABLE __AT_CMD_TASK__ MBEDTLS_CONFIG_FILE="<config-opl-default.h>"
  c misc: --preinclude=sys_common.h --preinclude=aliyun_config.h  --diag_suppress=1295  --diag_suppress=1 --diag_suppress=47
  c include: ..\..\..\..\APS\FreeRtos\Source\include;..\..\..\..\APS\FreeRtos\Source\portable\Keil\ARM_CM3;..\..\..\..\APS\driver\CMSIS\Include;..\..\..\..\APS\driver\CMSIS\Device\opl1000\Include;..\..\..\..\APS\driver\chip;..\..\..\..\APS\driver\chip\opl1000\securityipdriver;..\..\..\..\APS\driver\chip\opl1000\securityipdriver\lib;..\..\..\..\APS\driver\chip\opl1000\hal_auxadc;..\..\..\..\APS\driver\chip\opl1000\hal_system;..\..\..\..\APS\driver\chip\opl1000\hal_patch;..\..\..\..\APS\driver\chip\opl1000\hal_uart;..\..\..\..\APS\driver\chip\opl1000\hal_spi;..\..\..\..\APS\driver\chip\opl1000\hal_vic;..\..\..\..\APS\driver\chip\opl1000\hal_dbg_uart;..\..\..\..\APS\driver\chip\opl1000\hal_wdt;..\..\..\..\APS\driver\chip\opl1000\hal_dma;..\..\..\..\APS\driver\chip\opl1000\hal_tmr;..\..\..\..\APS\driver\chip\opl1000\hal_tick;..\..\..\..\APS\driver\chip\opl1000\hal_pwm;..\..\..\..\APS\driver\chip\opl1000\hal_i2c;..\..\..\..\APS\project\opl1000\include;..\..\..\..\APS\project\common;..\..\..\..\APS\middleware\netlink;..\..\..\..\APS\middleware\netlink\cli;..\..\..\..\APS\middleware\netlink\msg;..\..\..\..\APS\middleware\netlink\data_flow;..\..\..\..\APS\middleware\netlink\wifi_controller_layer;..\..\..\..\APS\middleware\netlink\ble_controller_layer\inc;..\..\..\..\APS\middleware\netlink\le_stack;..\..\..\..\APS\middleware\netlink\at;..\..\..\..\APS\middleware\netlink\iperf\inc;..\..\..\..\APS\middleware\netlink\controller_task;..\..\..\..\APS\middleware\netlink\ps_task;..\..\..\..\APS\middleware\netlink\diag_task;..\..\..\..\APS\middleware\netlink\wifi_mac;..\..\..\..\APS\apps\le_app\pts_app;..\..\..\..\APS\apps\le_app\mtc_app;..\..\..\..\APS\apps\le_app\cmd_app;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\lwip\src\include;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\ports\freertos\include;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\ports\freertos\netif;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\ports\rom_if;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\;..\..\..\..\APS\middleware\third_party\tinycrypt\include;..\..\..\..\APS\middleware\third_party\mbedtls\configs;..\..\..\..\APS\middleware\third_party\mbedtls\include;..\..\..\..\APS\middleware\third_party\mbedtls\port\include;..\..\..\..\APS\project\opl1000\boot_sequence;..\..\..\..\APS\project\opl1000\startup;..\..\..\driver\chip\opl1000\hal_system;..\..\..\middleware\netlink\diag_task;..\..\..\middleware\third_party\aliyun\iotx-sdk-c\include\exports;..\..\..\middleware\third_party\aliyun\iotx-sdk-c\include\imports;..\..\..\middleware\third_party\aliyun\iotx-sdk-c\include;..\..\..\middleware\third_party\aliyun\iotx-sdk-c\src\infra;..\..\..\middleware\third_party\aliyun\iotx-sdk-c\src\infra\log;..\..\..\middleware\third_party\aliyun\iotx-sdk-c\src\infra\system;..\..\..\middleware\third_party\aliyun\iotx-sdk-c\src\infra\utils;..\..\..\middleware\third_party\aliyun\iotx-sdk-c\src\infra\utils\digest;..\..\..\middleware\third_party\aliyun\iotx-sdk-c\src\infra\utils\misc;..\..\..\middleware\third_party\aliyun\iotx-sdk-c\src\sdk-impl;..\..\..\middleware\third_party\aliyun\iotx-sdk-c\src\protocol\mqtt;..\..\..\middleware\third_party\aliyun\iotx-sdk-c\src\protocol\mqtt\client;..\..\..\middleware\third_party\aliyun\iotx-sdk-c\src\protocol\mqtt\MQTTPacket;..\..\..\middleware\third_party\aliyun\iotx-sdk-c\src\ref-impl\hal;..\..\..\middleware\third_party\aliyun\config;..\..\..\middleware\third_party\aliyun\iotx-sdk-c\src\protocol\alcs;..\..\..\middleware\third_party\aliyun\iotx-sdk-c\src\protocol\coap\local;..\..\..\middleware\third_party\aliyun\iotx-sdk-c\src\services\linkkit\dm;..\..\..\middleware\third_party\aliyun\iotx-sdk-c\src\services\linkkit\cm;..\..\..\middleware\third_party\aliyun\iotx-sdk-c\src\services\linkkit\cm\include;..\..\..\middleware\third_party\aliyun\iotx-sdk-c\src\services\linkkit\dm\client;..\..\..\middleware\third_party\aliyun\iotx-sdk-c\src\services\linkkit\dm\server;..\..\..\middleware\third_party\aliyun\iotx-sdk-c\src\services\linkkit\dev_reset;..\..\..\middleware\third_party\aliyun\iotx-sdk-c\src\services\dev_bind;..\..\..\middleware\third_party\aliyun\iotx-sdk-c\src\services\awss;..\..\..\middleware\third_party\aliyun\iotx-sdk-c\src\services\dev_bind\os;..\..\..\middleware\third_party\aliyun\iotx-sdk-c\src\services\dev_bind\os\product;.\iotx-sdk-c\src\ref-impl\hal\os\freertos\kv\include;.\iotx-sdk-c\src\ref-impl\hal\os\freertos\kv\include\aos
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xc0000
  memory RVCT9: RAM 0x400000 size 0x50000
  group infra/log
    ./iotx-sdk-c/src/infra/log/: iotx_log.c
  group infra/system
    ./iotx-sdk-c/src/infra/system/: report.c guider.c device.c ca.c aos_support.c event.c
    ./iotx-sdk-c/src/infra/system/facility/: fac_string.c
  group infra/utils/digest
    ./iotx-sdk-c/src/infra/utils/digest/: utils_hmac.c utils_md5.c utils_sha1.c utils_base64.c
  group infra/utils/misc
    ./iotx-sdk-c/src/infra/utils/misc/: json_parser.c utils_httpc.c utils_net.c json_token.c mem_stats.c string_utils.c utils_timer.c lite-cjson.c utils_epoch_time.c utils_event.c
  group platform-hal
    ./iotx-sdk-c/src/ref-impl/hal/os/freertos/: HAL_Crypt_FreeRTOS.c HAL_OS_FreeRTOS.c HAL_TCP_FreeRTOS.c HAL_UDP_FreeRTOS.c
    ./iotx-sdk-c/src/ref-impl/hal/ssl/mbedtls/: HAL_TLS_mbedtls.c
  group sdk-impl
    ./iotx-sdk-c/src/sdk-impl/: impl_dynreg.c impl_linkkit.c sdk-impl.c
  group protocol/mqtt
    ./iotx-sdk-c/src/protocol/mqtt/MQTTPacket/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
    ./iotx-sdk-c/src/protocol/mqtt/client/: mqtt_client.c
  group protocol/httpc
    ./iotx-sdk-c/src/protocol/http/: iotx_http_api.c
  group protocol/alcs
    ./iotx-sdk-c/src/protocol/alcs/: alcs_adapter.c alcs_api.c alcs_client.c alcs_coap.c alcs_localsetup.c alcs_mqtt.c alcs_server.c
  group protocol/coap/local
    ./iotx-sdk-c/src/protocol/coap/local/: CoAPDeserialize.c CoAPExport.c CoAPMessage.c CoAPNetwork.c CoAPObserve.c CoAPPlatform.c CoAPResource.c CoAPSerialize.c CoAPServer.c
  group protocol/coap/cloud
    ./iotx-sdk-c/src/protocol/coap/cloud/: CoAPDeserialize.c CoAPExport.c CoAPMessage.c CoAPNetwork.c CoAPSerialize.c iotx_ca_cert.c iotx_coap_api.c
  group service/dm
    ./iotx-sdk-c/src/services/linkkit/dm/: dm_api.c dm_cota.c dm_fota.c dm_ipc.c dm_manager.c dm_message.c dm_message_cache.c dm_msg_process.c dm_opt.c dm_ota.c dm_shadow.c dm_tsl_alink.c dm_utils.c
    ./iotx-sdk-c/src/services/linkkit/dm/client/: dm_client.c dm_client_adapter.c
    ./iotx-sdk-c/src/services/linkkit/dm/server/: dm_server.c dm_server_adapter.c
  group service/cm
    ./iotx-sdk-c/src/services/linkkit/cm/: iotx_cm.c iotx_cm_coap.c iotx_cm_mqtt.c
  group service/dev_bind
    ./iotx-sdk-c/src/services/dev_bind/: awss_bind.c awss_cmp_coap.c awss_cmp_mqtt.c awss_event.c awss_notify.c awss_packet.c awss_report.c awss_timer.c passwd.c sha256.c
    ./iotx-sdk-c/src/services/dev_bind/os/: os_misc.c
  group service/linkkit/reset
    ./iotx-sdk-c/src/services/linkkit/dev_reset/: awss_reset.c
  group kv
    ./iotx-sdk-c/src/ref-impl/hal/os/freertos/kv/: aos_freertos.c kvmgr.c
