# Keil uVision project opl1000_sdk_m3.uvprojx, settings and files
target OPL1000_APS_SDK (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.1.1
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: opl1000_sdk_m3 +hex (library)
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: OPL1000_APS __noSIMULATOR__ __BLE__ __LE_HOST_USE_CMD__ __LWIP_TASK__ __WPA_SUPPLICANT__ __noHW_CRYPTO_ENGINE__ __WIFI_MAC_TASK__ __NL1000_An__ __PMP_ENABLE__ __PMP_REGION__ __HEAP_REGION__ noLWIP_DYNAMIC_DEBUG_ENABLE __AT_CMD_TASK__ __noRTL_SIMULATION__ __noATCWLAP_SCAN_HISTORY_EN__
  c misc: --preinclude=sys_common.h
  c include: ..\..\apps\le_app\cmd_app;..\..\apps\le_app\mtc_app;..\..\apps\le_app\pts_app;..\..\apps\wifi_app;..\..\driver\chip\opl1000\hal_auxadc;..\..\driver\chip\opl1000\hal_dbg_uart;..\..\driver\chip\opl1000\hal_dma;..\..\driver\chip\opl1000\hal_i2c;..\..\driver\chip\opl1000\hal_patch;..\..\driver\chip\opl1000\hal_pwm;..\..\driver\chip\opl1000\hal_spi;..\..\driver\chip\opl1000\hal_system;..\..\driver\chip\opl1000\hal_tick;..\..\driver\chip\opl1000\hal_tmr;..\..\driver\chip\opl1000\hal_uart;..\..\driver\chip\opl1000\hal_vic;..\..\driver\chip\opl1000\hal_wdt;..\..\driver\chip\opl1000\securityipdriver;..\..\driver\CMSIS\Device\opl1000\Include;..\..\driver\CMSIS\Include;..\..\FreeRtos\Source\include;..\..\FreeRtos\Source\portable\Keil\ARM_CM3;..\..\middleware\netlink\at;..\..\middleware\netlink\ble_controller_layer\inc;..\..\middleware\netlink\cli;..\..\middleware\netlink\common\sys_api;..\..\middleware\netlink\common\sys_api\rom_if;..\..\middleware\netlink\common\sys_ctrl;..\..\middleware\netlink\controller_task;..\..\middleware\netlink\data_flow;..\..\middleware\netlink\diag_task;..\..\middleware\netlink\le_stack;..\..\middleware\netlink\msg;..\..\middleware\netlink\mw_fim;..\..\middleware\netlink\mw_ota;..\..\middleware\netlink\ps_task;..\..\middleware\netlink\wifi_controller_layer;..\..\middleware\netlink\wifi_controller_layer\rom_if;..\..\middleware\netlink\wifi_mac;..\..\middleware\netlink\wifi_mac\common;..\..\middleware\netlink\wifi_mac\crypto;..\..\middleware\netlink\wifi_mac\utils;..\..\middleware\third_party\fatfs\src;..\..\middleware\third_party\httpclient;..\..\middleware\third_party\lwip-2.0.3;..\..\middleware\third_party\lwip-2.0.3\lwip\src\include;..\..\middleware\third_party\lwip-2.0.3\ports\freertos\include;..\..\middleware\third_party\lwip-2.0.3\ports\freertos\netif;..\..\middleware\third_party\lwip-2.0.3\ports\rom_if;..\..\middleware\third_party\mbedtls\configs;..\..\middleware\third_party\mbedtls\include\mbedtls;..\..\middleware\third_party\mbedtls\port\include;..\..\middleware\third_party\tinycrypt\include;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\ap;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\common;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\crypto;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\drivers;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\eapol_auth;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\eapol_supp;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\eap_common;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\eap_peer;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\eap_server;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\l2_packet;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\radius;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\rsn_supp;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\tls;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\utils;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\wps;..\..\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant;..\..\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant\dbus;..\common;boot_sequence;include;startup;..\..\..\APS_PATCH\apps\le_app\cmd_app;..\..\..\APS_PATCH\apps\le_app\mtc_app;..\..\..\APS_PATCH\apps\le_app\pts_app;..\..\..\APS_PATCH\apps\wifi_app;..\..\..\APS_PATCH\driver\chip\opl1000\hal_auxadc;..\..\..\APS_PATCH\driver\chip\opl1000\hal_dbg_uart;..\..\..\APS_PATCH\driver\chip\opl1000\hal_dma;..\..\..\APS_PATCH\driver\chip\opl1000\hal_i2c;..\..\..\APS_PATCH\driver\chip\opl1000\hal_patch;..\..\..\APS_PATCH\driver\chip\opl1000\hal_pwm;..\..\..\APS_PATCH\driver\chip\opl1000\hal_spi;..\..\..\APS_PATCH\driver\chip\opl1000\hal_system;..\..\..\APS_PATCH\driver\chip\opl1000\hal_tick;..\..\..\APS_PATCH\driver\chip\opl1000\hal_tmr;..\..\..\APS_PATCH\driver\chip\opl1000\hal_uart;..\..\..\APS_PATCH\driver\chip\opl1000\hal_vic;..\..\..\APS_PATCH\driver\chip\opl1000\hal_wdt;..\..\..\APS_PATCH\driver\chip\opl1000\securityipdriver;..\..\..\APS_PATCH\driver\CMSIS\Device\opl1000\Include;..\..\..\APS_PATCH\driver\CMSIS\Include;..\..\..\APS_PATCH\FreeRtos\Source\include;..\..\..\APS_PATCH\FreeRtos\Source\portable\Keil\ARM_CM3;..\..\..\APS_PATCH\middleware\netlink\at;..\..\..\APS_PATCH\middleware\netlink\ble_controller_layer\inc;..\..\..\APS_PATCH\middleware\netlink\cli;..\..\..\APS_PATCH\middleware\netlink\common\sys_api;..\..\..\APS_PATCH\middleware\netlink\common\sys_api\rom_if;..\..\..\APS_PATCH\middleware\netlink\common\sys_ctrl;..\..\..\APS_PATCH\middleware\netlink\controller_task;..\..\..\APS_PATCH\middleware\netlink\data_flow;..\..\..\APS_PATCH\middleware\netlink\diag_task;..\..\..\APS_PATCH\middleware\netlink\le_stack\patch;..\..\..\APS_PATCH\middleware\netlink\msg;..\..\..\APS_PATCH\middleware\netlink\mw_fim;..\..\..\APS_PATCH\middleware\netlink\mw_ota;..\..\..\APS_PATCH\middleware\netlink\ps_task;..\..\..\APS_PATCH\middleware\netlink\wifi_controller_layer;..\..\..\APS_PATCH\middleware\netlink\wifi_controller_layer\rom_if;..\..\..\APS_PATCH\middleware\netlink\wifi_mac;..\..\..\APS_PATCH\middleware\netlink\wifi_mac\common;..\..\..\APS_PATCH\middleware\netlink\wifi_mac\crypto;..\..\..\APS_PATCH\middleware\netlink\wifi_mac\utils;..\..\..\APS_PATCH\middleware\third_party\fatfs\src;..\..\..\APS_PATCH\middleware\third_party\httpclient;..\..\..\APS_PATCH\middleware\third_party\lwip-2.0.3;..\..\..\APS_PATCH\middleware\third_party\lwip-2.0.3\lwip\src\include;..\..\..\APS_PATCH\middleware\third_party\lwip-2.0.3\ports\freertos\include;..\..\..\APS_PATCH\middleware\third_party\lwip-2.0.3\ports\freertos\netif;..\..\..\APS_PATCH\middleware\third_party\lwip-2.0.3\ports\rom_if;..\..\..\APS_PATCH\middleware\third_party\mbedtls\configs;..\..\..\APS_PATCH\middleware\third_party\mbedtls\include\mbedtls;..\..\..\APS_PATCH\middleware\third_party\mbedtls\port\include;..\..\..\APS_PATCH\middleware\third_party\tinycrypt\include\tinycrypt;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\ap;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\common;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\crypto;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\drivers;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\eapol_auth;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\eapol_supp;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\eap_common;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\eap_peer;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\eap_server;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\l2_packet;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\radius;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\rsn_supp;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\tls;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\utils;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\wps;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant\dbus;..\..\..\APS_PATCH\project\common;..\..\..\APS_PATCH\project\opl1000\boot_sequence;..\..\..\APS_PATCH\project\opl1000\include;..\..\..\APS_PATCH\project\opl1000\startup;..\..\..\APS_PATCH\FreeRtos\Source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xc0000
  memory RVCT9: RAM 0x400000 size 0x50000
  group Source
    ../../../APS_PATCH/project/opl1000/startup/: sys_init_patch.c opl1000_it_patch.c
  group Drivers
    ../../../APS_PATCH/driver/chip/opl1000/hal_system/: hal_system_patch.c hal_gpio.c hal_pin_patch.c
    ../../../APS_PATCH/driver/chip/opl1000/hal_vic/: hal_vic_patch.c
    ../../../APS_PATCH/driver/chip/opl1000/hal_spi/: hal_spi_patch.c hal_flash_patch.c
    ../../../APS_PATCH/driver/chip/opl1000/hal_dbg_uart/: hal_dbg_uart_patch.c
    ../../../APS_PATCH/driver/chip/opl1000/hal_uart/: hal_uart_patch.c
    ../../../APS_PATCH/driver/chip/opl1000/hal_auxadc/: hal_auxadc_patch.c
  group at
    ../../../APS_PATCH/middleware/netlink/at/: at_cmd_func_patch.c at_cmd_sys_patch.c at_cmd_task_patch.c at_cmd_app_patch.c at_cmd_tcpip_patch.c at_cmd_wifi_patch.c at_cmd_common_patch.c at_cmd_data_process_patch.c at_cmd_ext_patch.c at_cmd_patch.c at_cmd_msg_ext_patch.c at_cmd_ble_patch.c at_cmd_rf_patch.c
  group wpa_supplicant
    ../../../APS_PATCH/middleware/third_party/wpa_supplicant-0.7.3/wpa_supplicant/: wpa_cli.c events_netlink_patch.c
    ../../../APS_PATCH/middleware/third_party/wpa_supplicant-0.7.3/src/drivers/: driver_netlink_patch.c
  group lwip
    ../../../APS_PATCH/middleware/third_party/lwip-2.0.3/ports/rom_if/: lwip_jmptbl_patch.c
    ../../../APS_PATCH/middleware/third_party/lwip-2.0.3/: lwip_helper_patch.c
    ../../../APS_PATCH/middleware/third_party/lwip-2.0.3/ports/freertos/netif/: wlannetif_patch.c
    ../../../APS_PATCH/middleware/third_party/lwip-2.0.3/lwip/src/api/: tcpip_patch.c
    ../../../APS_PATCH/middleware/third_party/lwip-2.0.3/lwip/src/core/: tcp_patch.c timeouts_patch.c tcp_out_patch.c
    ../../../APS_PATCH/middleware/third_party/lwip-2.0.3/lwip/src/core/ipv4/: dhcp_patch.c etharp_patch.c
    ../../../APS_PATCH/middleware/third_party/lwip-2.0.3/lwip/src/netif/: ethernet_patch.c
  group http_client
    ../../../APS_PATCH/middleware/third_party/httpclient/: httpclient.c
  group mw_fim
    ../../../APS_PATCH/middleware/netlink/mw_fim/: mw_fim_patch.c mw_fim_default_group01_patch.c
  group common
    ../../../APS_PATCH/middleware/netlink/common/sys_api/: sys_common_api_patch.c
target OPL1000_APS_SDK_Lite (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.1.1
  cpu: as above
  output: opl1000_sdk_m3_lite +hex (library)
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: OPL1000_APS __noSIMULATOR__ __BLE__ __LE_HOST_USE_CMD__ __LWIP_TASK__ __WPA_SUPPLICANT__ __noHW_CRYPTO_ENGINE__ __WIFI_MAC_TASK__ __NL1000_An__ __PMP_ENABLE__ __PMP_REGION__ __HEAP_REGION__ noLWIP_DYNAMIC_DEBUG_ENABLE __AT_CMD_TASK__ __noRTL_SIMULATION__ __noATCWLAP_SCAN_HISTORY_EN__ SDK_LITE
  c misc: --preinclude=sys_common.h
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xc0000
  memory RVCT9: RAM 0x400000 size 0x50000
